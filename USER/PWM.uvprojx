# Keil uVision project PWM.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\Customer;..\HARDWARE\Public;..\HARDWARE\Robot;..\HARDWARE\sys
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Main
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Robot
    ../HARDWARE/Robot/: Robot.c Robot_Command.c Robot_Fault.c Robot_Flash.c Robot_Gear.c Robot_Head_LED.c Robot_IPK_Fault.c Robot_LED.c Robot_LPF.c Robot_Poweron.c Robot_Sample.c Robot_State.c
  group SYS
    ../HARDWARE/sys/: sys.c
  group Public
    ../HARDWARE/Public/: Public.c
  group Customer
    ../HARDWARE/Customer/: Customer.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_sdio.c
